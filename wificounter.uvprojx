# Keil uVision project wificounter.uvprojx, settings and files
target STM32F723-DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723ICKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x40000) IROM2(0x00200000,0x40000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: wificounter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\drivers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Drivers
    ./src/drivers/: hal_gpio_driver.h hal_gpio_driver.c
  group Main
    ./src/: main.c led.c led.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.2.0
